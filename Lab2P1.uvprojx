# Keil uVision project Lab2P1.uvprojx, settings and files
target Blinky (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Lab2P1
  c flags: Optim=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./: adc0.c adc16.c Blinky.c timers.c adc16.h Blinkly.h timers.h uart.c uart.h global_var.c global_var.h ADC_Kit.c ADC_Kit.h adc0.h PWM_Kit.c PWM_Kit.h Kit_chain.h Kit_chain.c core_algorithm.c
  group ::Device
    RTE/Device/MKL25Z128xxx4/: startup_MKL25Z4.s system_MKL25Z4.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
